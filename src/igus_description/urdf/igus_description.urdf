Commit message: simple update

File: src/igus_description/urdf/igus_description.urdf (robot description, URDF)
Before this commit: robot igus_description, 6 links, 5 joints
Joints:
- joint base_joint: origin xyz=0.0 0.0 0.0 rpy=0 0 0 -> xyz=0.0 0.0 0.0 rpy=0 0 3.142
